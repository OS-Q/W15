# Keil uVision project ucosiii.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ucos
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\user\;..\UCOS_III\uC-CPU\cfg;..\UCOS_III\uC-LIB\cfg;..\UCOS_III\uCOS-III\cfg;..\UCOS_III\uCOS-III\Ports;..\UCOS_III\uCOS-III\Source;..\UCOS_III\uC-CPU\Port;..\UCOS_III\uC-LIB\Ports;..\UCOS_III\uC-CPU;..\UCOS_III\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: bsp.c main.c stm32f0xx_it.c
  group CMSIS
    ../Libraries/CMSIS/Device/Source/: system_stm32f0xx.c startup_stm32f030.s
  group uC_LIB
    ../UCOS_III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC_CPU
    ../UCOS_III/uC-CPU/: cpu_core.c
    ../UCOS_III/uC-CPU/Port/: cpu_a.asm cpu_c.c
  group uCOS_III
    ../UCOS_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../UCOS_III/uCOS-III/Ports/: os_cpu_c.c os_cpu_a.s
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
software components: CMSIS:CORE 5.1.1
